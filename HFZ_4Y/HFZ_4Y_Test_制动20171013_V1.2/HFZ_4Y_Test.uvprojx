# Keil uVision project HFZ_4Y_Test.uvprojx, settings and files
target HFZ_4Y_Test (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: HFZ_4Y_Test +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o D:\相旭\新仪表\20171120\单机添加握手加密和心跳指令\添加看门狗\HFZ_4Y_Test_制动20171013_V1.2\OUTPUT\HFZ_4Y_Test.bin D:\相旭\新仪表\20171120\单机添加握手加密和心跳指令\添加看门狗\HFZ_4Y_Test_制动20171013_V1.2\OUTPUT\HFZ_4Y_Test.axf
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\boot;.\cmsis;.\FWLib\inc;.\user;.\user\AES
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x70000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group boot
    ./boot/: startup_stm32f10x_hd.s
  group user_app
    ./user/: stm32f10x_it.c main.c user_app.c Cabrate_Computer.c SystemErr.c
  group cmsis
    ./cmsis/: system_stm32f10x.c core_cm3.c
  group FWLib
    ./FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group ad7663
    ./user/: ad7663.c ad7663_app.c
  group usart
    ./user/: user_usart.c
  group w25q64
    ./user/: flash_spi.c
  group IO_set
    ./user/: user_io.c
  group data_all
    ./user/: user_data.c
  group w5500
    ./user/: W5500.c W5500_APP.c
  group 说明
    ./: 说明.txt 版本更新说明.txt
  group AES
    ./user/AES/: AES.lib
software components: CMSIS:CORE 5.0.1
