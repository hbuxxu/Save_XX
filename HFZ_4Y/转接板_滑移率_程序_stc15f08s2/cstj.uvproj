# Keil uVision project cstj.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: cstj +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: C:\Keil_v5\C51\INC\STC;C:\Keil\C51\INC\STC
  group Source Group 1
    ./: STARTUP.A51 cstj.c 说明.txt
